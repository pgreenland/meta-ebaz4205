# Use file hosted in repo
HDF_PATH = "github.com/pgreenland/ebaz4205_xsa.git;branch=rel-v2021.2"
HDF_NAME = "ebaz4205_top.xsa"
SRCREV = "6c57dd8e2512f650dd8d43cb06ba46c7b256dd22"

# Use local file
#HDF_BASE = "file://"
#HDF_PATH = "/home/user/work/ebaz4205_fpga/build/ebaz4205_top.xsa"

HDF_MACHINE = ""
